# Keil uVision project QM003_V2.uvprojx, settings and files
target QM003 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: QM003
  AfterMake: fromelf.exe --bin -o "#L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\Libraries\audio\inc;..\src\inc;..\Libraries\bluetooth\inc;..\Libraries\fs\inc;..\Libraries\os\inc;..\Libraries\character_encoding\inc;..\src\du_params;..\src\slave_uart;..\src\wifi;..\Libraries\driver\inc;..\src\fm_driver
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\MVs18.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_suppress=L6314W,L6319W
  group main
    ../src/main/: main.c task_main.c task_bt.c task_decoder.c task_audio_process.c startup.c
  group libs
    ../Libraries/bluetooth/: bt.lib
    ../Libraries/fs/: fs.lib
    ../Libraries/driver/: driver.lib
    ../Libraries/os/: freertos.lib
    ../Libraries/audio/: audio_utility.lib audio_bluetooth.lib audio_decoder.lib audio_encoder.lib three_d.lib echo.lib libmp3enc.lib sra.lib dc_blocker.lib drc.lib virtual_bass.lib adpcm_encoder.lib silence_detector.lib
    ../Libraries/character_encoding/: character_encoding.lib
  group dev_detect
    ../src/dev_detect/: dev_detect_driver.c dev_state_machine.c
  group control
    ../src/key/: coding_key.c
    ../src/control/: player_control.c line_in_control.c radio_control.c usb_audio_control.c rtc_control.c recorder_control.c bt_hf_control.c idle_control.c i2s_in_control.c
  group bluetooth
    ../src/bluetooth/: bt_app_func.c bt_app_ui_callback.c bt_device_cfg.c bt_play_internal_api.c bte2prom.c obex_spp_proc.c pcm_sync.c spp_app_proc.c ble_app_callback.c ble_app_example.c ble_app_pseudocode.c
  group key
    ../src/key/: key.c adc_key.c ir_key.c power_key.c iic_key.c gpio_key.c adc_adjust_vol.c
  group fs
    ../src/fs/: diskio.c filesort.c partition.c presearch.c
  group fm_driver
    ../src/fm_driver/: radio.c i2c.c QN8035.c mtk_fm_drv.c RDA5807.c
  group sys_app
    ../src/sys_app/: breakpoint.c sys_app.c sys_vol.c sound_remind.c power_management.c browser.c micro_adjust.c mcu_circular_buf.c spi_slave.c rtc_at8563.c audio_file.c
  group misc
    ../src/misc/: get_bootup_info.c sw_uart.c mass_test.c debug_test.c upgrade_detect.c retarget.c gd_flash_drv.c
    ../src/du_params/: eq_params.c
  group inc
    ../src/inc/: app_config.h app_msg.h sys_app.h sys_vol.h breakpoint.h player_control.h radio_control.h recorder_control.h usb_audio_control.h rtc_control.h idle_control.h line_in_control.h task_decoder.h dev_detect_driver.h key.h power_monitor.h sound_remind.h string_convert.h sw_uart.h eq_params.h browser.h micro_adjust.h
  group display
    ../src/display/: led_display.c seg_led_disp.c seg_panel.c aip1629a.c singled_display.c
  group WiFi
    ../src/wifi/: wifi_control.c wifi_uart_com.c wifi_bt_control.c
