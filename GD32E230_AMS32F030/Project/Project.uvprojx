# Keil uVision project Project.uvprojx, settings and files
target GD32E230 (6120000::V6.12::.\ARMCLANG)
  device: GD32E230K6 GigaDevice
  pack: GigaDevice.GD32E230_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0001800) IROM(0x08000000,0x0008000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\GD32E230\Firmware\CMSIS;..\Function;..\GD32E230\Utilities;..\GD32E230\Firmware\CMSIS\GD\GD32E230\Include;..\GD32E230\Firmware\GD32E230_standard_peripheral\Include;..\GD32E230\Platform
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Function
    ../Function/: timeout_api.c main.c single_pwm_led.c single_pwm_light.c
  group GD_Platform
    ../GD32E230/Platform/: gd32e230_it.c GDPlatformconfig.c
    ../GD32E230/Firmware/CMSIS/GD/GD32E230/Source/: system_gd32e230.c
    ../GD32E230/Firmware/CMSIS/GD/GD32E230/Source/ARM/: startup_gd32e230.s
  group GD_Peripherals
    ../GD32E230/Firmware/GD32E230_standard_peripheral/Source/: gd32e230_adc.c gd32e230_cmp.c gd32e230_crc.c gd32e230_dbg.c gd32e230_dma.c gd32e230_exti.c gd32e230_fmc.c gd32e230_fwdgt.c gd32e230_gpio.c gd32e230_i2c.c gd32e230_misc.c gd32e230_pmu.c gd32e230_rcu.c gd32e230_rtc.c gd32e230_spi.c gd32e230_syscfg.c gd32e230_timer.c gd32e230_usart.c gd32e230_wwdgt.c
  group Utilities
    ../GD32E230/Utilities/: gd32e230c_eval.c
  group ASM_Peripherals
    ../AMS32F030/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group ASM_Platform
    ../AMS32F030/Platform/: stm32f0xx_it.c AsmPlatformconfig.c stm32f0xx_pwm.c gpio_key.c
    ../AMS32F030/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../AMS32F030/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
    ../AMS32F030/Utilities/STM32_EVAL/STM32072B_EVAL/: stm32072b_eval.c
target ASM32F030 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ASM32F030 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030,USE_FULL_ASSERT
  c misc: --C99
  c include: ..\AMS32F030\Platform;..\Function;..\AMS32F030\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\AMS32F030\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\AMS32F030\Libraries\CMSIS\Include;..\AMS32F030\Libraries\STM32F0xx_CPAL_Driver\inc;..\AMS32F030\Libraries\CMSIS\RTOS;..\AMS32F030\Utilities\STM32_EVAL\STM32072B_EVAL;..\AMS32F030\Utilities\STM32_EVAL\Common;..\AMS32F030\Utilities\STM32_EVAL\STM320518_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.2.0
